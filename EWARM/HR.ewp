# IAR project HR.ewp, settings and files
configuration STM32L4_IOT_HR (ARM)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L475xx; USE_STM32L475E_IOT01; USE_HAL_DRIVER; SET_L2CAP_CONN_UPD_REQ_COMMAND; ENABLE_SPI_FIX; BLUENRG_MS
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\Common\ble_core\; ..\..\Common\ble_services\; ..\..\Common\debug\; ..\..\Common\hw\; ..\..\Common\tl\; ..\..\Common\utilities\; ..\..\Common\; ..\Inc\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Dory.srec
  ILINK.IlinkOutputFile: BLE.out
  ILINK.IlinkIcfFile: stm32l475xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Common/ble_core
    ../../Common/ble_core/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c osal.c
  group Application/Common/ble_services
    ../../Common/ble_services/: dis.c hrs.c svc_ctl.c
  group Application/Common/hw_interface
    ../../Common/hw/: hw_lpm.c hw_spi.c hw_timerserver.c
  group Application/Common/tl
    ../../Common/tl/: tl_ble_hci.c tl_ble_io.c tl_ble_reassembly.c tl_ble_spi.c
  group Application/Common/utilities
    ../../Common/utilities/: list.c lpm.c memory_manager.c scheduler.c
  group Application/HR_Example
    ../Src/: dis_app.c hr.c hrs_app.c main.c stm32l4xx_it.c system_stm32l4xx.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ./: startup_stm32l475xx.s
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c
